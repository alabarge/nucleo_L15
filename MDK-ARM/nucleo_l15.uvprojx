# Keil uVision project nucleo_l15.uvprojx, settings and files
target nucleo_L15 (6160000::V6.16::ARMCLANG)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20013FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: nucleo_l15 +hex
  BeforeMake: ..\L15_fw\script\pre_build.bat ..\L15_fw\build.inc ..\L15_fw\build.h ..\.git
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L152xE
  c include: ../Core/Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L1xx/Include; ../Drivers/CMSIS/Include;../L15_fw;../L15_fw/core;../L15_fw/driver;../L15_fw/cp_srv;../L15_fw/daq_srv;../L15_fw/share
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group Application/MDK-ARM
    ./: startup_stm32l152xe.s
  group Application/User/Core
    ../L15_fw/core/: user_main.c user_main.h cli.c cli.h cli_lib.c cli_defs.h cli_lib.h cm.c cm.h msg_str.h io.h lib.c lib.h rec_types.h
    ../L15_fw/share/: cm_msg.h cm_const.h fw_cfg.h ee_type.h type.h build.h
    ../L15_fw/cp_srv/: cp_hal.c cp_hal.h cp_msg.h cp_srv.c cp_srv.h
    ../L15_fw/daq_srv/: daq_hal.c daq_hal.h daq_msg.h daq_srv.c daq_srv.h
    ../L15_fw/driver/: adc.c adc.h uart.c uart.h xlprint.c xlprint.h
    ../Core/Src/: main.c stm32l1xx_it.c stm32l1xx_hal_msp.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_exti.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l1xx.c
software components: CMSIS:CORE 5.5.0
