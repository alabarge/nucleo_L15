# Keil uVision project nucleo_L15.uvprojx, settings and files
target stm32 (6160000::V6.16::ARMCLANG)
  device: STM32L152RETx STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.4.1
  cpu: IRAM(0x20000000,0x00014000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: nucleo_L15 +hex
  BeforeMake: .\L15_fw\script\pre_build.bat .\L15_fw\build.inc .\L15_fw\build.h .\.git
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ./L15_fw;./L15_fw/core;./L15_fw/driver;./L15_fw/cp_srv;./L15_fw/daq_srv;./L15_fw/share
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group Application
    ./L15_fw/core/: cli.c cli.h cli_defs.h cli_lib.c cli_lib.h cm.c cm.h io.h lib.c lib.h msg_str.h rec_types.h user_main.c user_main.h
    ./L15_fw/cp_srv/: cp_hal.c cp_hal.h cp_msg.h cp_srv.c cp_srv.h
    ./L15_fw/daq_srv/: daq_hal.c daq_hal.h daq_msg.h daq_srv.c daq_srv.h
    ./L15_fw/driver/: adc.c adc.h uart.c uart.h xlprint.c xlprint.h
    ./L15_fw/share/: cm_const.h cm_msg.h ee_type.h fw_cfg.h type.h
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L152RETx/STCubeGenerated/Src/: main.c stm32l1xx_it.c
    ./RTE/Device/STM32L152RETx/STCubeGenerated/Inc/: stm32l1xx_it.h
software components: CMSIS:CORE 5.6.0, Device:STM32Cube HAL 1.10.3
